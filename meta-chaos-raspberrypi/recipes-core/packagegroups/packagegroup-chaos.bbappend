RDEPENDS_${PN} += " \
    udev-rules-rpi \
    homebridge-energenie-ener314rt \
    "
